# Keil uVision project RunGenerator.uvprojx, settings and files
target RunGenerator (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RunGenerator
  AfterMake: d:\Program Files (x86)\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\RunGenerator.axf --output Objects\RunGenerator.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HD44780;.\HD44780\drivers;.\onewire;.\RTC;.\KeyPad;.\ADC;.\Flash
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c
  group LCD1602
    ./HD44780/: hd44780.c
    ./HD44780/drivers/: hd44780_stm32f10x.c
  group onewire
    ./onewire/: onewire.c onewire.h
  group RTC
    ./RTC/: rtc.c rtc.h
  group KeyPad
    ./KeyPad/: KeyPad.c KeyPad.h
  group ADC
    ./ADC/: adc.c adc.h
  group Flash
    ./Flash/: flash.c flash.h
software components: CMSIS:CORE 5.2.0, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
